# Keil uVision project HRtimer.uvprojx, settings and files
target HRtimer (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F334C6 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: HRtimer
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F334x8
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_tim.c stm32f3xx_hal_dma.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_adc.c stm32f3xx_hal.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_uart.c stm32f3xx_hal_flash.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Application/User
    ../Src/: stm32f3xx_it.c main.c adc.c stm32f3xx_hal_msp.c usart.c hrtim.c gpio.c comp.c dac.c utils.c
software components: CMSIS:CORE 4.1.0
